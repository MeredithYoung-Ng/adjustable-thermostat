# Keil uVision project fan_control.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.10.0.0
  cpu: IRAM(0x1fff0000,0x010000) IRAM2(0x20000000,0x030000) IROM(0x00000000,0x100000) XRAM(0x14000000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: fan_control
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT6: RAM 0x14000000 size 0x1000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: .\RTE\Device\MK64FN1M0VLL12\MK64FN1M0xxx12_flash.scf
  group Source Group 1
    ./: main.c converter.c init.c init.h converter.h seg_lib.c seg_lib.h
software components: CMSIS:CORE 5.0.1, Board Support:Buttons 1.2, Board Support:LED 1.2, Device:KSDK Configuration:FRDM-K64F 1.2.0, Device:KSDK Driver:GPIO 1.2.0, Device:KSDK Driver:RTC 1.2.0, Device:KSDK Driver:eDMA 1.2.0, Device:KSDK HAL:DAC 1.2.0, Device:KSDK HAL:DMAMUX 1.2.0, Device:KSDK HAL:GPIO 1.2.0, Device:KSDK HAL:LPTMR 1.2.0, Device:KSDK HAL:MCG 1.2.0, Device:KSDK HAL:OSC 1.2.0, Device:KSDK HAL:PORT 1.2.0, Device:KSDK HAL:RTC 1.2.0, Device:KSDK HAL:SIM 1.2.0, Device:KSDK HAL:UART 1.2.0, Device:KSDK HAL:eDMA 1.2.0, Device:KSDK OSA:OSA 1.2.0, Device:KSDK System:Clock 1.2.0, Device:KSDK System:Interrupt 1.2.0, Device:KSDK Utility:Debug Console 1.2.0, Device:Startup 2.8, Device:SDK Drivers:adc 2.0.0, Device:SDK Drivers:clock 2.1.0, Device:SDK Drivers:common 2.0.0, Device:SDK Drivers:dac 2.0.1, Device:SDK Drivers:gpio 2.2.1, Device:SDK Drivers:pit 2.0.0
